## config/boards/shields/customtap/Kconfig.defconfig
```kconfig
if SHIELD_CUSTOMTAP

config ZMK_KEYBOARD_NAME
    default "Wooden Artist"

endif
```
